# Keil uVision project myProject_rtx.uvprojx, settings and files
target default (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProject_rtx
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: OSAPI_USE_RTX
  c include: .\cunit\Headers;.\osapi;.\osapi_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ./application/: main.cpp
  group cunit
    ./cunit/Sources/Basic/: Basic.c
    ./cunit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
  group osapi
    ./osapi/: osapi.h osapi_mortal_thread.h osapi_mutex_interface.h osapi_thread_interface.h
    ./osapi/rtx/: osapi_thread_rtx.h osapi_rtx.cpp osapi_mutex_rtx.h osapi_recursive_mutex_rtx.h
  group osapi_test
    ./osapi_test/: test_00_thread_name.cpp test_01_thread_creation.cpp test_02_thread_join.cpp test_03_thread_suspend_resume.cpp test_04_thread_delay.cpp test_05_thread_priority.cpp test_06_thread_priority_change.cpp test_07_thread_run_detailed.cpp test_08_thread_state.cpp test_09_thread_suspend_inactive.cpp test_10_thread_stack_size.cpp test_20_mutex.cpp test_21_recursive_mutex.cpp test_30_mortal_thread.cpp test_osapi.cpp test_osapi.h
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
